# Keil uVision project project.uvprojx, settings and files
target rtthread (6160000::V6.16::ARMCLANG)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.40.3
  cpu: IRAM(0x20000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NRF52840_XXAA, RT_USING_ARMLIBC, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, __RTTHREAD__
  c include: ..\libraries\cmsis\include;..\..\..\components\drivers\include;board;packages\nrfx-latest\mdk;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\libraries\drivers;packages\nrfx-latest\drivers;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\libc\posix\ipc;packages\nrfx-latest\drivers\src;packages\nrfx-latest\hal;..\..\..\include;..\..\..\components\libc\compilers\common\include;..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\posix\io\poll;..\..\..\components\drivers\include;packages\nrfx-latest;..\..\..\libcpu\arm\common;applications;packages\nrfx-latest\drivers\include;.;..\..\..\components\finsh;..\..\..\components\libc\posix\io\stdio
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: application.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    board/: board.c
    ../libraries/drivers/: drv_gpio.c drv_uart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group nrf_Drivers
    packages/nrfx-latest/drivers/src/: nrfx_comp.c nrfx_twis.c nrfx_usbd.c nrfx_nfct.c nrfx_nvmc.c nrfx_gpiote.c nrfx_spi.c nrfx_usbreg.c nrfx_saadc.c nrfx_timer.c nrfx_i2s.c nrfx_ipc.c nrfx_dppi.c nrfx_spim.c nrfx_clock.c nrfx_qdec.c nrfx_systick.c nrfx_twim.c nrfx_spis.c nrfx_ppi.c nrfx_twi_twim.c nrfx_pdm.c nrfx_twi.c nrfx_qspi.c nrfx_uart.c nrfx_lpcomp.c nrfx_rtc.c nrfx_wdt.c nrfx_adc.c nrfx_rng.c nrfx_egu.c nrfx_pwm.c nrfx_uarte.c nrfx_power.c nrfx_temp.c
    packages/nrfx-latest/mdk/: arm_startup_nrf52840.s system_nrf52840.c
